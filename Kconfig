## Kconfig
```kconfig
config IGLOO
	bool "IGLOO module support"
	default y
	help
      Support for IGLOO analysis
```
